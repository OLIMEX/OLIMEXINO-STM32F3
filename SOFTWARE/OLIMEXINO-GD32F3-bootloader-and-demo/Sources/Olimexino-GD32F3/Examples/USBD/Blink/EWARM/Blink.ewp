# IAR project Blink.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: GD32F303xC GigaDevice GD32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F30X_HD
  ICCARM.CCIncludePath2: ..\..\..\..\Firmware\CMSIS\GD\GD32F30x\Include; ..\..\..\..\Utilities; ..\..\..\..\Firmware\GD32F30x_usbd_library\device\Include; ..\..\..\..\Firmware\GD32F30x_usbd_library\usbd\Include; ..\..\..\..\Firmware\GD32F30x_usbd_library\class\device\cdc\Include; ..\..\..\..\Firmware\GD32F30x_standard_peripheral\Include; ..\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Blink.bin
  ILINK.IlinkOutputFile: Olimexino-GD32F3.out
  ILINK.IlinkIcfFile: D:\Repository_SVN\GD\OLIMEXINO-GD32F3\Software\trunk\Prodution_Test\Olimexino-GD32F3\Examples\USBD\Blink\EWARM\Custom_GD32F303xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Custom_GD32F303xC.icf
  group Appliction
    ../src/: gd32f30x_it.c LEDs_Button.c main.c systick.c
  group CMSIS
    ../src/: system_gd32f30x.c
  group GD32F30x_EVAL
    ../../../../Utilities/: gd32f303e_eval.c
  group GD32F30x_Peripherals
    ../../../../Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_timer.c
  group Startup
    ../../../../Firmware/CMSIS/GD/GD32F30x/Source/IAR/: startup_gd32f30x_hd.s
